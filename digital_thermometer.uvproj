# Keil uVision project digital_thermometer.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: digital_thermometer +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: digital_thermometer.c real_clock.c real_clock.h
